# Keil uVision project project.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.10.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,PLATFORM=SX12xxEiger,STM32F4XX
  c include: ..\BSP_USER\LED;..\CORE;..\Common;..\STM32f4_LIB\inc;..\SYSTEM;..\BSP_USER\USART2;..\BSP_USER\ESP8266;..\ONENET;..\ONENET\mqtt;..\Utils;..\SX1278\radio;..\SX1278\platform\sx12xxEiger;..\SX1278\platform;..\APP;..\BSP_USER\KEY;..\SX1278
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f40_41xxx.s
  group SYSTEM
    ../SYSTEM/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group BSP_USER
    ../BSP_USER/LED/: led.c
    ../BSP_USER/USART2/: usart2.c
    ../BSP_USER/ESP8266/: esp8266.c
    ../BSP_USER/KEY/: key.c
  group Common
    ../Common/: delay.c sys.c usart1.c
  group STM32F4_LIB
    ../STM32f4_LIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_dma.c stm32f4xx_spi.c
  group PROTOCOL
    ../ONENET/: onenet_hal.c
    ../SX1278/: lora_network.c lora_network_node.c
  group UTILS
    ../Utils/: cJSON.c utils.c
  group Radio
    ../SX1278/radio/: radio.c sx1276.c sx1276-Fsk.c sx1276-FskMisc.c sx1276-LoRa.c sx1276-LoRaMisc.c
  group SX12xxEiger
    ../SX1278/platform/sx12xxEiger/: fifo.c spi.c sx12xxEiger.c sx1276-Hal.c
  group APP
    ../APP/: app.c
software components: CMSIS:CORE 5.0.2, RTOS:device drivers 2.1.2, RTOS:kernel 2.1.2, RTOS:shell 2.1.2
